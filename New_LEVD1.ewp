# IAR project New_LEVD1.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2452.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptStrategy: 1
  group (top)
    ./: AdcReader.c EreaseInformationMemory.c IIC_Slave.c InputSignalGetting.c LEDDisplay.c LEDDisplay_5LEDScan.c LEDDisplay_5LEDScanFull.c LEV_CommonDefine.h LEV_PrjDefine.h LEVD1_Main.c main.c MosFETControl.c SW_Button.c TimerA.c
  group SOC
    SOC/: CoulombCounter.c SOC_Calculation.c SOC_OCV_Table.h
  group SystemInitialData
    SystemInitialData/: CalculatingSettingProtectionToADC.c CommonSysInforDefine.h InformationFlashAccess.c SystemConfigInitial.s43 SystemInformation.h SystemInformation_Thick_36V.h SystemInformation_Thick_48V.h SystemInformation_ThinType36V.h
